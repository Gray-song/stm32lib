# Keil uVision project platform.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: platform +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_HD
  c include: ..\sys;..\drv\inc;..\hal\inc;..\app\inc
  memory RVCT4: ROM 0x8008000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group test
    ./: test.c
  group drv
    ../drv/src/: drv_clock.c drv_gpio.c drv_systick.c drv_usart.c drv_nvic.c drv_iwdg.c drv_timer.c drv_adc.c drv_dac.c
  group hal
    ../hal/src/: hal_clock.c hal.c hal_gpio.c hal_systick.c hal_usart.c hal_nvic.c hal_iwdg.c hal_timer.c hal_adc.c hal_dac.c
  group sys
    ../sys/: startup_stm32f10x_hd.s
